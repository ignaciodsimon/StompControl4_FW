# Keil uVision project newFW.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F60XE Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: newFW +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c mcu_definitions.h uart.h uart.c eeprom.h eeprom.c
    ./: newUI.c
